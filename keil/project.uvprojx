# Keil uVision project project.uvprojx, settings and files
target project (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project +hex
  BeforeMake: G:\gerenkesan\MCU_KaFa\TI\project\tools\keil\syscfg.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\project_PID_Vtiaoca_chonggou;.\hardware;.\mpu6050;..\..\..\..\..\..\source\ti\iqmath\_IQNfunctions;..\..\..\..\..\..\source\ti\iqmath\include;..\..\..\..\..\..\source\third_party\CMSIS\Core\Include;..\..\..\..\..\..\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Startup
    ./: startup_mspm0g350x_uvision.s
  group Source
    ../../../../../../source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_comp.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_gpamp.c dl_gpio.c dl_i2c.c dl_iwdt.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc.c dl_rtc_a.c dl_rtc_b.c dl_rtc_common.c dl_scratchpad.c dl_spi.c dl_tamperio.c dl_timer.c dl_timera.c dl_timerg.c dl_trng.c dl_uart.c dl_vref.c dl_wwdt.c
    ../../../../../../source/ti/driverlib/m0p/: dl_factoryregion.c dl_interrupt.c
    ../../../../../../source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c dl_sysctl_mspm0g1x0x_g3x0x.h
    ../../../../../../source/ti/iqmath/_IQNfunctions/: _atoIQN.c _IQNasin_acos.c _IQNatan2.c _IQNdiv.c _IQNexp.c _IQNfrac.c _IQNlog.c _IQNmpy.c _IQNmpyIQX.c _IQNrepeat.c _IQNrmpy.c _IQNrsmpy.c _IQNsin_cos.c _IQNsqrt.c _IQNtables.c _IQNtoa.c _IQNtoF.c _IQNversion.c
  group User
    ../: main.c main.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
    ./hardware/: main.h
  group Hardware
    ./hardware/: LCD.c motor.c usart.c xunji.c Key.c Key.h PID.c
  group MPU6050
    ./mpu6050/: IIC.c MPU6050.c inv_mpu.c inv_mpu_dmp_motion_driver.c
